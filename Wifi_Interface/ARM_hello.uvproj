# Keil uVision project ARM_hello.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LM3S308 Luminary Micro
  cpu: IRAM(0x20000000-0x20000FFF) IROM(0-0x3FFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: ARM_hello
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group Source Group 1
    ./: Startup.s arm_hello.c
