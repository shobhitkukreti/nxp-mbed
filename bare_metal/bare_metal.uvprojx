# Keil uVision project bare_metal.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.0.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: bare_metal
  c flags: Optim=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Source Group 1
    ./: main.c
  group ::Device
    C:/Keil_v5/ARM/PACK/Keil/LPC1700_DFP/2.0.0/RTE_Driver/: GPDMA_LPC17xx.c GPIO_LPC17xx.c PIN_LPC17xx.c
    RTE/Device/LPC1768/: RTE_Device.h startup_LPC17xx.s system_LPC17xx.c
software components: CMSIS:CORE 3.40.0, Device:GPDMA 1.00, Device:GPIO 1.00, Device:PIN 1.00, Device:Startup 1.0.0
